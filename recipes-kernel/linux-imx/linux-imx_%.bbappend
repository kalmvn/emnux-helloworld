FILESEXTRAPATH:prepend = "${THISDIR}/files"
SRC_URI: += " file://0001-add-i2c4-userspace-dts.patch"


FILESEXTRAPATH:prepend = "${THISDIR}/imx8mm-ddr4:"
SRC_URI: += " file://0001-add-i2c4-userspace-dts.patch"

